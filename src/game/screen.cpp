#include "screen.h"

namespace gfx {

// Classic 5x7 ASCII font, 0x20..0x7E. Column-major: each byte is one pixel
// column, bit 0 the top row.
static const uint8_t FONT5X7[][5] = {
  {0x00,0x00,0x00,0x00,0x00}, {0x00,0x00,0x5F,0x00,0x00}, {0x00,0x07,0x00,0x07,0x00},
  {0x14,0x7F,0x14,0x7F,0x14}, {0x24,0x2A,0x7F,0x2A,0x12}, {0x23,0x13,0x08,0x64,0x62},
  {0x36,0x49,0x55,0x22,0x50}, {0x00,0x05,0x03,0x00,0x00}, {0x00,0x1C,0x22,0x41,0x00},
  {0x00,0x41,0x22,0x1C,0x00}, {0x14,0x08,0x3E,0x08,0x14}, {0x08,0x08,0x3E,0x08,0x08},
  {0x00,0x50,0x30,0x00,0x00}, {0x08,0x08,0x08,0x08,0x08}, {0x00,0x60,0x60,0x00,0x00},
  {0x20,0x10,0x08,0x04,0x02}, {0x3E,0x51,0x49,0x45,0x3E}, {0x00,0x42,0x7F,0x40,0x00},
  {0x42,0x61,0x51,0x49,0x46}, {0x21,0x41,0x45,0x4B,0x31}, {0x18,0x14,0x12,0x7F,0x10},
  {0x27,0x45,0x45,0x45,0x39}, {0x3C,0x4A,0x49,0x49,0x30}, {0x01,0x71,0x09,0x05,0x03},
  {0x36,0x49,0x49,0x49,0x36}, {0x06,0x49,0x49,0x29,0x1E}, {0x00,0x36,0x36,0x00,0x00},
  {0x00,0x56,0x36,0x00,0x00}, {0x08,0x14,0x22,0x41,0x00}, {0x14,0x14,0x14,0x14,0x14},
  {0x00,0x41,0x22,0x14,0x08}, {0x02,0x01,0x51,0x09,0x06}, {0x32,0x49,0x79,0x41,0x3E},
  {0x7E,0x11,0x11,0x11,0x7E}, {0x7F,0x49,0x49,0x49,0x36}, {0x3E,0x41,0x41,0x41,0x22},
  {0x7F,0x41,0x41,0x22,0x1C}, {0x7F,0x49,0x49,0x49,0x41}, {0x7F,0x09,0x09,0x09,0x01},
  {0x3E,0x41,0x49,0x49,0x7A}, {0x7F,0x08,0x08,0x08,0x7F}, {0x00,0x41,0x7F,0x41,0x00},
  {0x20,0x40,0x41,0x3F,0x01}, {0x7F,0x08,0x14,0x22,0x41}, {0x7F,0x40,0x40,0x40,0x40},
  {0x7F,0x02,0x0C,0x02,0x7F}, {0x7F,0x04,0x08,0x10,0x7F}, {0x3E,0x41,0x41,0x41,0x3E},
  {0x7F,0x09,0x09,0x09,0x06}, {0x3E,0x41,0x51,0x21,0x5E}, {0x7F,0x09,0x19,0x29,0x46},
  {0x46,0x49,0x49,0x49,0x31}, {0x01,0x01,0x7F,0x01,0x01}, {0x3F,0x40,0x40,0x40,0x3F},
  {0x1F,0x20,0x40,0x20,0x1F}, {0x3F,0x40,0x38,0x40,0x3F}, {0x63,0x14,0x08,0x14,0x63},
  {0x07,0x08,0x70,0x08,0x07}, {0x61,0x51,0x49,0x45,0x43}, {0x00,0x7F,0x41,0x41,0x00},
  {0x02,0x04,0x08,0x10,0x20}, {0x00,0x41,0x41,0x7F,0x00}, {0x04,0x02,0x01,0x02,0x04},
  {0x40,0x40,0x40,0x40,0x40}, {0x00,0x01,0x02,0x04,0x00}, {0x20,0x54,0x54,0x54,0x78},
  {0x7F,0x48,0x44,0x44,0x38}, {0x38,0x44,0x44,0x44,0x20}, {0x38,0x44,0x44,0x48,0x7F},
  {0x38,0x54,0x54,0x54,0x18}, {0x08,0x7E,0x09,0x01,0x02}, {0x0C,0x52,0x52,0x52,0x3E},
  {0x7F,0x08,0x04,0x04,0x78}, {0x00,0x44,0x7D,0x40,0x00}, {0x20,0x40,0x44,0x3D,0x00},
  {0x7F,0x10,0x28,0x44,0x00}, {0x00,0x41,0x7F,0x40,0x00}, {0x7C,0x04,0x18,0x04,0x78},
  {0x7C,0x08,0x04,0x04,0x78}, {0x38,0x44,0x44,0x44,0x38}, {0x7C,0x14,0x14,0x14,0x08},
  {0x08,0x14,0x14,0x18,0x7C}, {0x7C,0x08,0x04,0x04,0x08}, {0x48,0x54,0x54,0x54,0x20},
  {0x04,0x3F,0x44,0x40,0x20}, {0x3C,0x40,0x40,0x20,0x7C}, {0x1C,0x20,0x40,0x20,0x1C},
  {0x3C,0x40,0x30,0x40,0x3C}, {0x44,0x28,0x10,0x28,0x44}, {0x0C,0x50,0x50,0x50,0x3C},
  {0x44,0x64,0x54,0x4C,0x44}, {0x00,0x08,0x36,0x41,0x00}, {0x00,0x00,0x7F,0x00,0x00},
  {0x00,0x41,0x36,0x08,0x00}, {0x08,0x08,0x2A,0x1C,0x08},
};

static constexpr int CELL_W = 6;   // 5 columns + 1 of spacing
static constexpr int CELL_H = 8;

int Screen::text(int x, int y, const char *s, bool on) {
  const int left = x;
  for (; *s; s++) {
    if (*s == '\n') { x = left; y += CELL_H; continue; }
    unsigned char c = (unsigned char)*s;
    if (c < 0x20 || c > 0x7E) c = '?';
    const uint8_t *g = FONT5X7[c - 0x20];
    for (int col = 0; col < 5; col++)
      for (int row = 0; row < 7; row++)
        if (g[col] & (1 << row)) pixel(x + col, y + row, on);
    x += CELL_W;
  }
  return x;
}

int Screen::textWidth(const char *s) {
  int w = 0, best = 0;
  for (; *s; s++) {
    if (*s == '\n') { w = 0; continue; }
    w += CELL_W;
    if (w > best) best = w;
  }
  return best;
}

// The outline is the set of unlit pixels that touch a lit one, so the letter
// keeps its scaled shape and gains a border without growing into its
// neighbours. A scratch Screen holds the solid form while it is traced.
int Screen::textBubble(int x, int y, const char *s, int scale, bool on) {
  static Screen scratch;  // 1KB, not on the stack: the ESP32's is small.
  scratch.clear();
  const int end = scratch.textScaled(x, y, s, scale, true);

  const int h = 7 * scale;
  for (int py = y - 1; py <= y + h; py++) {
    for (int px = x - 1; px <= end; px++) {
      if (scratch.pixelAt(px, py)) continue;
      bool edge = false;
      for (int dy = -1; dy <= 1 && !edge; dy++)
        for (int dx = -1; dx <= 1 && !edge; dx++)
          if (scratch.pixelAt(px + dx, py + dy)) edge = true;
      if (edge) pixel(px, py, on);
    }
  }
  return end;
}

// --- 3x5 label font --------------------------------------------------------
// Column-major like FONT5X7, but 3 columns of 5 rows. Grid labels have to fit
// beside a 5px cell, which a 7-row glyph cannot do.
static const uint8_t FONT3X5_DIGIT[10][3] = {
  {0x1F,0x11,0x1F}, {0x12,0x1F,0x10}, {0x1D,0x15,0x17}, {0x11,0x15,0x1F},
  {0x07,0x04,0x1F}, {0x17,0x15,0x1D}, {0x1F,0x15,0x1D}, {0x01,0x19,0x07},
  {0x1F,0x15,0x1F}, {0x17,0x15,0x1F},
};

static const uint8_t FONT3X5_ALPHA[26][3] = {
  {0x1E,0x05,0x1E}, {0x1F,0x15,0x0A}, {0x0E,0x11,0x11}, {0x1F,0x11,0x0E},
  {0x1F,0x15,0x15}, {0x1F,0x05,0x05}, {0x0E,0x11,0x1D}, {0x1F,0x04,0x1F},
  {0x11,0x1F,0x11}, {0x08,0x10,0x0F}, {0x1F,0x04,0x1B}, {0x1F,0x10,0x10},
  {0x1F,0x02,0x1F}, {0x1F,0x0E,0x1F}, {0x0E,0x11,0x0E}, {0x1F,0x05,0x02},
  {0x0E,0x19,0x1E}, {0x1F,0x0D,0x16}, {0x12,0x15,0x09}, {0x01,0x1F,0x01},
  {0x0F,0x10,0x0F}, {0x07,0x18,0x07}, {0x1F,0x0C,0x1F}, {0x1B,0x04,0x1B},
  {0x03,0x1C,0x03}, {0x19,0x15,0x13},
};

static constexpr int TINY_W = 3;
static constexpr int TINY_CELL = 4;  // 3 columns + 1 of spacing

// The tiny font carries digits and capitals only. A slash earns its place
// because the side gutters count things -- "3/5" -- and without it the pair
// reads as two unrelated numbers with a hole between them.
static const uint8_t FONT3X5_SLASH[3] = {0x18, 0x0E, 0x03};
// A hyphen, because a board's name is "esp-red" and a gap where the dash
// should be reads as two names rather than one.
static const uint8_t FONT3X5_DASH[3] = {0x04, 0x04, 0x04};

int Screen::textTiny(int x, int y, const char *s, bool on) {
  for (; *s; s++) {
    // Folded to capitals rather than dropped. There is one case in this font
    // and the panels are all capitals anyway, so a name typed in the browser
    // as "nirvek" has to draw as NIRVEK -- before this it drew as nothing at
    // all, which read as an empty row rather than as a player.
    char c = *s;
    if (c >= 'a' && c <= 'z') c -= 'a' - 'A';
    const uint8_t *g = nullptr;
    if (c >= '0' && c <= '9') g = FONT3X5_DIGIT[c - '0'];
    else if (c >= 'A' && c <= 'Z') g = FONT3X5_ALPHA[c - 'A'];
    else if (c == '/') g = FONT3X5_SLASH;
    else if (c == '-') g = FONT3X5_DASH;
    if (g) {
      for (int col = 0; col < TINY_W; col++)
        for (int row = 0; row < 5; row++)
          if (g[col] & (1 << row)) pixel(x + col, y + row, on);
    }
    x += TINY_CELL;
  }
  return x;
}

int Screen::textTinyWidth(const char *s) {
  int n = 0;
  for (; *s; s++) n++;
  return n ? n * TINY_CELL - 1 : 0;
}

int Screen::textScaled(int x, int y, const char *s, int scale, bool on) {
  if (scale <= 1) return text(x, y, s, on);
  const int left = x;
  for (; *s; s++) {
    if (*s == '\n') { x = left; y += CELL_H * scale; continue; }
    unsigned char c = (unsigned char)*s;
    if (c < 0x20 || c > 0x7E) c = '?';
    const uint8_t *g = FONT5X7[c - 0x20];
    for (int col = 0; col < 5; col++)
      for (int row = 0; row < 7; row++)
        if (g[col] & (1 << row))
          fillRect(x + col * scale, y + row * scale, scale, scale, on);
    x += CELL_W * scale;
  }
  return x;
}

// Two strokes, thickened by drawing each one twice a pixel apart, so the mark
// reads at a glance from across a table rather than as a hairline.
int centerScaledX(const char *s, int scale) {
  int w = Screen::textScaledWidth(s, scale);
  if (w > 0) w -= scale;  // the trailing gap after the last glyph
  return (W - w) / 2;
}

int centerTextX(const char *s) { return centerScaledX(s, 1); }

int centerTinyIn(const char *s, int left, int right) {
  int w = Screen::textTinyWidth(s);
  if (w > 0) w -= 1;  // the trailing gap after the last glyph
  return left + (right - left + 1 - w) / 2;
}

void drawTick(Screen &s, int x, int y, int size, bool on) {
  if (size < 4) return;
  const int shortArm = size / 3;      // down-right into the elbow
  const int longArm = size - shortArm;
  const int elbowX = x + shortArm, elbowY = y + size - 1;
  for (int d = 0; d < 2; d++) {
    for (int i = 0; i < shortArm; i++)
      s.pixel(x + i, elbowY - shortArm + 1 + i + d, on);
    for (int i = 0; i < longArm; i++)
      s.pixel(elbowX + i, elbowY - i + d, on);
  }
}

void drawCross(Screen &s, int x, int y, int size, bool on) {
  if (size < 4) return;
  for (int d = 0; d < 2; d++)
    for (int i = 0; i < size; i++) {
      s.pixel(x + i, y + i + d, on);
      s.pixel(x + size - 1 - i, y + i + d, on);
    }
}

}  // namespace gfx
